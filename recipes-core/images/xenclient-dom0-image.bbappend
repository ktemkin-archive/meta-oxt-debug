PR .= ".2"
IMAGE_INSTALL += " \
    task-core-tools-debug \
    xen-tools-xenconsole \
    qemu-dm-dbg \
    stubdom-debug-tools \
    "
