PR .= ".3"
IMAGE_INSTALL += " \
    task-core-tools-debug \
    systemtap \
    systemtap-uprobes \
    kernel-vmlinux \
    "

